{attribute 'qualified_only'}
VAR_GLOBAL
	stComIn    AT %I* : ST_KL6781inData22B;
    stComOut   AT %Q* : ST_KL6781outData22B;
    stCom            : ST_MBUS_Communication;
END_VAR
